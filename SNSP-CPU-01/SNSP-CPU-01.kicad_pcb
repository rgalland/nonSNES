# Repository rgalland/nonSNES (continued)

## KiCad design SNSP-CPU-01/SNSP-CPU-01.kicad_pcb (continued)

Board: 2 copper layers, 215.8 x 159.0 mm, 400 parts (339 on the bottom side), 364 nets.
