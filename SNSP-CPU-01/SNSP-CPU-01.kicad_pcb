# Repository rgalland/nonSNES

## KiCad design SNSP-CPU-01/SNSP-CPU-01.kicad_pcb

Parts:
C1, C3, C44, C45, C47, C48, C49, C50, C51, C52: 47pF; C_0805_2012Metric
C2: 15pF; C_0805_2012Metric
C4, C5, C69: 47pF; C_0805_2012Metric; not fitted
C6, C7, C8, C29, C31, C32, C33, C34, C80, C82, C84, C85, C88, C89, C90, C91, C92, C93, C94, C95, C96, C97, C98, C99, C100, C101, C102: 0.1µF; C_0805_2012Metric
C9, C74, C77: 1nF; C_0805_2012Metric
C10, C11, C70: 82pF; C_0805_2012Metric
C12, C17, C19, C86: 10pF; C_0805_2012Metric
C13, C15: 220pF; C_0805_2012Metric
C14, C16, C18, C23, C24, C25, C26, C27, C28, C53, C54, C81: 1uF; C_0805_2012Metric
C20, C55: C; C_Axial_L3.8mm_D2.6mm_P12.50mm_Horizontal
C21, C56: C; C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal
C22, C35, C36, C37, C38, C39, C40, C41, C42, C43, C46: 330pF; C_0805_2012Metric
C30, C83: 0.01uF; C_0805_2012Metric
C59, C60, C61, C66: 10uF 50V; C_Elec_6.3x5.4
C62: 2.2uF; CP_Elec_4x5.8
C63, C64: 33uF 25V; CP_Elec_6.3x3
C65: 10u 50V; C_Elec_6.3x5.4
C67: 2200uF; CP_Radial_D16.0mm_P7.50mm
C68: 56pF; C_0805_2012Metric
C73: 47u 10V; C_Elec_6.3x5.4
C75, C78: 1800pF; C_0805_2012Metric
C76, C79: 100pF; C_0805_2012Metric
D1: D_Zener_Dual_CommonCathode_AAK_Split; SC-59
D2, D3, D4, D5, D6, D7: D; D_T-1_P5.08mm_Horizontal
DA1, DA2, DA3, DA4, DA5: DAP202; SC-59
DA6, DA7, DA8, DA9, DA10, DA12, DA13, DA14, DA15, DA16, DA17, DA18, DA19, DA20: DAN202; SC-59
DA11: DAN217; SC-59
DB1: D_Bridge_+A-A; FullBridgeRectifier
F1: Fuse
H1, H2: MountingHole; MountingHole_2.5mm
J1: Jack-DC; DcJack
J2: RFModulator
J3: Conn_02x06_Odd_Even; PinSocket_2x06_P2.54mm_Vertical
J4: CONTROLLER 1; Controller
J5: CONTROLLER 2; Controller
L1: 22u; Fuse_1210_3225Metric
LED1: Red; LED_D5.0mm_Horizontal_O6.35mm_Z3.0mm
O4: 160 Ω; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
P1: CASSETTE
P2, P7: JST 11FE-BT-VK-N; JST_ZE_Controllers
P3: Conn_01x02_Pin; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
P4: AVOut
P5: EXPANSION
P6: AVOut_Internal
Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10, Q11, Q12, Q13, Q14, Q15, Q16, Q17: C2412K; SC-59
Q18: 2SC5658; SC-59
R1, R3, R35, R37: 270; R_0805_2012Metric
R2, R106, R107: 5.1k; R_0805_2012Metric
R4, R5, R6, R24, R32, R42, R45, R108, R109, R110, R111: 100; R_0805_2012Metric; not fitted
R7, R12, R17: 30; R_0805_2012Metric
R8, R13, R18: 1.1k; R_0805_2012Metric
R9, R14, R19: 1.5k; R_0805_2012Metric
R10, R15, R20, R23, R31, R39, R44, R53, R54, R55, R60, R61, R62, R66, R69, R70, R71, R77, R78, R79, R80, R81, R82, R92, R97: 10k; R_0805_2012Metric
R11, R16, R21: 120; R_0805_2012Metric
R22, R30, R38, R43: 470; R_0805_2012Metric
R25, R33: 22; R_0805_2012Metric
R26, R57, R64, R76: 1.8k; R_0805_2012Metric
R27, R83, R84, R85, R86, R87, R88, R98: 100; R_0805_2012Metric
R28, R29: 3.3k; R_0805_2012Metric
R34, R36, R49, R52, R58, R59, R65, R67, R72: 1k; R_0805_2012Metric
R40, R41, R46: 39; R_0805_2012Metric
R47: 1k; R_0805_2012Metric; not fitted
R48, R50, R51: 33k; R_0805_2012Metric
R56, R63: 24k; R_0805_2012Metric
R68: 47k; R_0805_2012Metric
R73: 0; R_0805_2012Metric
R74: 2.2k; R_0805_2012Metric
R75: 100k; R_0805_2012Metric
R89, R90, R91: 10; R_0805_2012Metric
R93, R94, R95, R96: 200; R_0805_2012Metric
R99, R101, R102, R103, R104, R105: 22k; R_0805_2012Metric
SW1: KB; SW_Cherry_MX_1.00u_PCB
SW2: Old; ResetSwitch
T1: L_Coupled; L_CommonMode_Delevan_4222
TC1: 20p; SurftrimGKG
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP30, TP31, TP32, TP33, TP34, TP35, TP36, TP37, TP38, TP39, TP40, TP41, TP42, TP43, TP44, TP45, TP46, TP47, TP48, TP49, TP50, TP51, TP52, TP53, TP54, TP55, TP56, TP57, TP58, TP59, TP60, TP61, TP62, TP63, TP64, TP65, TP66, TP67, TP68, TP69, TP70, TP71, TP72, TP73, TP74, TP75, TP76, TP77, TP78, TP79, TP80, TP81, TP82, TP83, TP84, TP85, TP86, TP87, TP88, TP89, TP90, TP91, TP92, TP93, TP94, TP95, TP96, TP97, TP98, TP99, TP100, TP101, TP102, TP103, TP104, TP105, TP106, TP107: TestPoint; TestPoint_Pad_D1.0mm
U1: CPU; PQFP-100_14x20mm_P0.65mm
U2: PPU1; PQFP-100_14x20mm_P0.65mm
U3: PPU2; PQFP-100_14x20mm_P0.65mm
U4, U5, U15, U16: MS62256CL-10FC; RAM
U6: WRAM; SOP-64_11x28mm_P0,75mm
U7: S-ENC; SO-24_5.3x15mm_P1.27mm
U8: CIC; SOIC-18_7x12mm_P0,8mm
U10: LM324; SO-14_3.9x8.65mm_P1.27mm
U11: LM809; SOT-23
U12: L7805; TO-220-3_Vertical
U13: S-SMP; PQFP-64_14x20mm_P1mm
U14: S-DSP; PQFP-80_15x22mm_P0.8mm
U17: UPD6376; SOIC-16_4.55x10.3mm_P1.27mm
U18: S-CLK; SOIC-14_3.9x8.7mm_P1.27mm
VA1: Varistor; D_3220_8050Metric
X1: 17.734MHz; Crystal_HC49-4H_Vertical
X2: 24.576MHz; Resonator-2Pin_W7.0mm_H2.5mm

Connections:
5MIN: U2.93 (5MOUT), U2.97 (5MIN), U3.38 (5MIN)
+9V: C80.2, Q16.3 (C), Q17.3 (C), Q18.2 (E), R47.2, R49.2, R50.2, U10.4 (V+)
+12V: C46.1, D1.3 (K), P4.3 (CSYNC), R72.1
/4016.D0: DA3.2 (K), DA8.2 (K), R81.2, R87.2, U1.32 (4016D0)
/4016.D1: DA3.1 (K), DA8.1 (A), R82.2, R88.2, U1.33 (4016D1)
/4017.D0: DA4.2 (K), DA9.2 (K), R79.2, R85.2, U1.27 (4017D0)
/4017.D1: DA4.1 (K), DA9.1 (A), R80.2, R86.2, U1.28 (4017D1)
/CA0: P1.17 (A0), U1.93 (A0), U6.23 (A0)
/CA1: P1.16 (A1), U1.94 (A1), U6.25 (A1)
/CA2: P1.15 (A2), U1.95 (A2), U6.27 (A2)
/CA3: P1.14 (A3), U1.96 (A3), U6.29 (A3)
/CA4: P1.13 (A4), U1.97 (A4), U6.31 (A4)
/CA5: P1.12 (A5), TP88.1 (1_1), U1.98 (A5), U6.35 (A5)
/CA6: P1.11 (A6), TP86.1 (1_1), U1.99 (A6), U6.37 (A6)
/CA7: P1.10 (A7), TP85.1 (1_1), U1.100 (A7), U6.39 (A7)
/CA8: P1.9 (A8), TP87.1 (1_1), U1.2 (A8), U6.41 (A8)
/CA9: P1.8 (A9), U1.3 (A9), U6.24 (A9)
/CA10: P1.7 (A10), U1.4 (A10), U6.26 (A10)
/CA11: P1.6 (A11), TP84.1 (1_1), U1.5 (A11), U6.28 (A11)
/CA12: P1.37 (A12), TP83.1 (1_1), U1.6 (A12), U6.30 (A12)
/CA13: P1.38 (A13), TP82.1 (1_1), U1.7 (A13), U6.34 (A13)
/CA14: P1.39 (A14), TP81.1 (1_1), U1.8 (A14), U6.36 (A14)
/CA15: P1.40 (A15), TP80.1 (1_1), U1.9 (A15), U6.38 (A15)
/CA16: P1.41 (A16), TP79.1 (1_1), U1.10 (A16), U6.40 (A16)
/CA17: P1.42 (A17), TP78.1 (1_1), U1.11 (A17)
/CA18: P1.43 (A18), TP77.1 (1_1), U1.12 (A18)
/CA19: P1.44 (A19), TP76.1 (1_1), U1.13 (A19)
/CA20: P1.45 (A20), TP75.1 (1_1), U1.14 (A20)
/CA21: P1.46 (A21), TP74.1 (1_1), U1.15 (A21)
/CA22: P1.47 (A22), TP73.1 (1_1), U1.16 (A22), U6.42 (ENA)
/CA23: P1.48 (A23), TP72.1 (1_1), U1.17 (A23)
/D0: P1.19 (D0), P5.11 (D0), TP3.1 (1_1), U1.60 (D0), U2.21 (D0), U3.15 (D0), U6.60 (D0), U13.45 (D0)
/D1: P1.20 (D1), P5.12 (D1), TP4.1 (1_1), U1.61 (D1), U2.20 (D1), U3.14 (D1), U6.61 (D1), U13.44 (D1)
/D2: P1.21 (D2), P5.13 (D2), TP5.1 (1_1), U1.62 (D2), U2.19 (D2), U3.13 (D2), U6.62 (D2), U13.43 (D2)
/D3: P1.22 (D3), P5.14 (D3), TP6.1 (1_1), U1.63 (D3), U2.18 (D3), U3.12 (D3), U6.63 (D3), U13.42 (D3)
/D4: P1.50 (D4), P5.15 (D4), TP7.1 (1_1), U1.64 (D4), U2.17 (D4), U3.11 (D4), U6.2 (D4), U13.41 (D4)
/D5: P1.51 (D5), P5.16 (D5), TP8.1 (1_1), U1.65 (D5), U2.16 (D5), U3.10 (D5), U6.3 (D5), U13.40 (D5)
/D6: P1.52 (D6), P5.17 (D6), TP9.1 (1_1), U1.66 (D6), U2.15 (D6), U3.9 (D6), U6.4 (D6), U13.39 (D6)
/D7: P1.53 (D7), P5.18 (D7), TP10.1 (1_1), U1.67 (D7), U2.14 (D7), U3.8 (D7), U6.5 (D7), U13.38 (D7)
/JPCLK1: DA2.2 (K), DA7.2 (K), R89.2, U1.35 (JOY-2-CLK)
/JPCLK2: DA2.1 (K), DA7.1 (A), R90.2, U1.36 (JOY-1-CLK)
/JPIO6: DA5.2 (K), DA10.2 (K), R77.2, R83.2, U1.25 (PP6)
/JPSTR: DA1.1 (K), DA6.2 (K), R91.2, U1.37 (JOY-OUT0)
/MA0: U14.9 (MA0), U15.10 (A0), U16.10 (A0)
/MA1: U14.10 (MA1), U15.9 (A1), U16.9 (A1)
/MA2: U14.11 (MA2), U15.8 (A2), U16.8 (A2)
/MA3: U14.13 (MA3), U15.7 (A3), U16.7 (A3)
/MA4: U14.14 (MA4), U15.6 (A4), U16.6 (A4)
/MA5: U14.15 (MA5), U15.5 (A5), U16.5 (A5)
/MA6: U14.16 (MA6), U15.4 (A6), U16.4 (A6)
/MA7: U14.17 (MA7), U15.3 (A7), U16.3 (A7)
/MA8: U14.34 (MA8), U15.25 (A8), U16.25 (A8)
/MA9: U14.32 (MA9), U15.24 (A9), U16.24 (A9)
/MA10: U14.29 (MA10), U15.21 (A10), U16.21 (A10)
/MA11: U14.31 (MA11), U15.23 (A11), U16.23 (A11)
/MA12: U14.18 (MA12), U15.2 (A12), U16.2 (A12)
/MA13: U14.35 (MA13), U15.26 (A13), U16.26 (A13)
/MA14: U14.19 (MA14), U15.1 (A14), U16.1 (A14)
/MD0: U14.8 (MD0), U15.11 (Q0), U16.11 (Q0)
/MD1: U14.7 (MD1), U15.12 (Q1), U16.12 (Q1)
/MD2: U14.6 (MD2), U15.13 (Q2), U16.13 (Q2)
/MD3: U14.22 (MD3), U15.15 (Q3), U16.15 (Q3)
/MD4: U14.23 (MD4), U15.16 (Q4), U16.16 (Q4)
/MD5: U14.24 (MD5), U15.17 (Q5), U16.17 (Q5)
/MD6: U14.25 (MD6), U15.18 (Q6), U16.18 (Q6)
/MD7: U14.26 (MD7), U15.19 (Q7), U16.19 (Q7)
/PA0: P1.28 (PA0), P5.1 (PA0), TP11.1 (1_1), U1.51 (PA0), U2.12 (PA0), U3.24 (PA0), U6.53 (PA0), U13.49 (A0)
/PA1: P1.59 (PA1), P5.2 (PA1), TP12.1 (1_1), U1.52 (PA1), U2.11 (PA1), U3.23 (PA1), U6.54 (PA1), U13.48 (A1)
/PA2: P1.29 (PA2), P5.3 (PA2), TP13.1 (1_1), U1.53 (PA2), U2.10 (PA2), U3.22 (PA2), U6.43 (PS1)
/PA3: P1.60 (PA3), P5.4 (PA3), TP14.1 (1_1), U1.54 (PA3), U2.9 (PA3), U3.21 (PA3), U6.44 (PS2)
/PA4: P1.30 (PA4), P5.5 (PA4), TP15.1 (1_1), U1.55 (PA4), U2.8 (PA4), U3.20 (PA4), U6.45 (PS3)
/PA5: P1.61 (PA5), P5.6 (PA5), TP16.1 (1_1), U1.56 (PA5), U2.7 (PA5), U3.19 (PA5), U6.46 (PS4)
/PA6: P1.3 (PA6), P5.7 (PA6), TP17.1 (1_1), U1.57 (PA6), U2.6 (PA6), U3.18 (PA6), U6.47 (PS5), U13.50 (CS)
/PA7: P1.34 (PA7), P5.8 (PA7), TP18.1 (1_1), U1.58 (PA7), U2.5 (PA7), U3.17 (PA7), U6.50 (PS1), U13.51 (~CS)
/VA14: U2.47 (VA15), U4.1 (A14), U5.1 (A14)
/VAA0: TP47.1 (1_1), U2.76 (VAA0), U5.10 (A0)
/VAA1: TP48.1 (1_1), U2.75 (VAA1), U5.9 (A1)
/VAA2: TP49.1 (1_1), U2.74 (VAA2), U5.8 (A2)
/VAA3: TP50.1 (1_1), U2.73 (VAA3), U5.7 (A3)
/VAA4: TP51.1 (1_1), U2.72 (VAA4), U5.6 (A4)
/VAA5: TP52.1 (1_1), U2.71 (VAA5), U5.5 (A5)
/VAA6: TP53.1 (1_1), U2.70 (VAA6), U5.4 (A6)
/VAA7: TP54.1 (1_1), U2.69 (VAA7), U5.3 (A7)
/VAA8: U2.68 (VAA8), U5.25 (A8)
/VAA9: U2.67 (VAA9), U5.24 (A9)
/VAA10: U2.66 (VAA10), U5.21 (A10)
/VAA11: U2.65 (VAA11), U5.23 (A11)
/VAA12: U2.64 (VAA12), U5.2 (A12)
/VAA13: U2.63 (VAA13), U5.26 (A13)
/VAB0: TP107.1 (1_1), U2.61 (VAB0), U4.10 (A0)
/VAB1: TP94.1 (1_1), U2.60 (VAB1), U4.9 (A1)
/VAB2: TP95.1 (1_1), U2.59 (VAB2), U4.8 (A2)
/VAB3: TP96.1 (1_1), U2.58 (VAB3), U4.7 (A3)
/VAB4: TP97.1 (1_1), U2.57 (VAB4), U4.6 (A4)
/VAB5: TP98.1 (1_1), U2.56 (VAB5), U4.5 (A5)
/VAB6: TP99.1 (1_1), U2.55 (VAB6), U4.4 (A6)
/VAB7: TP100.1 (1_1), U2.54 (VAB7), U4.3 (A7)
/VAB8: TP101.1 (1_1), U2.53 (VAB8), U4.25 (A8)
/VAB9: TP102.1 (1_1), U2.52 (VAB9), U4.24 (A9)
/VAB10: TP103.1 (1_1), U2.51 (VAB10), U4.21 (A10)
/VAB11: TP104.1 (1_1), U2.50 (VAB11), U4.23 (A11)
/VAB12: TP105.1 (1_1), U2.49 (VAB12), U4.2 (A12)
/VAB13: TP106.1 (1_1), U2.48 (VAB13), U4.26 (A13)
/VDA0: TP55.1 (1_1), U2.37 (VDA0), U3.60 (VDA0), U5.11 (Q0)
/VDA1: TP56.1 (1_1), U2.38 (VDA1), U3.61 (VDA1), U5.12 (Q1)
/VDA2: TP57.1 (1_1), U2.39 (VDA2), U3.62 (VDA2), U5.13 (Q2)
/VDA3: TP58.1 (1_1), U2.40 (VDA3), U3.63 (VDA3), U5.15 (Q3)
/VDA4: TP59.1 (1_1), U2.41 (VDA4), U3.64 (VDA4), U5.16 (Q4)
/VDA5: TP60.1 (1_1), U2.42 (VDA5), U3.65 (VDA5), U5.17 (Q5)
/VDA6: TP61.1 (1_1), U2.43 (VDA6), U3.66 (VDA6), U5.18 (Q6)
/VDA7: TP62.1 (1_1), U2.44 (VDA7), U3.67 (VDA7), U5.19 (Q7)
/VDB0: TP39.1 (1_1), U2.28 (VDB0), U3.51 (VDB0), U3.69 (EXT0), U4.11 (Q0)
/VDB1: TP40.1 (1_1), U2.29 (VDB1), U3.52 (VDB1), U3.70 (EXT1), U4.12 (Q1)
/VDB2: TP41.1 (1_1), U2.30 (VDB2), U3.53 (VDB2), U3.71 (EXT2), U4.13 (Q2)
/VDB3: TP42.1 (1_1), U2.31 (VDB3), U3.54 (VDB3), U3.72 (EXT3), U4.15 (Q3)
/VDB4: TP43.1 (1_1), U2.32 (VDB4), U3.55 (VDB4), U3.73 (EXT4), U4.16 (Q4)
/VDB5: TP44.1 (1_1), U2.33 (VDB5), U3.56 (VDB5), U3.74 (EXT5), U4.17 (Q5)
/VDB6: TP45.1 (1_1), U2.34 (VDB6), U3.57 (VDB6), U3.75 (EXT6), U4.18 (Q6)
/VDB7: TP46.1 (1_1), U2.35 (VDB7), U3.58 (VDB7), U3.76 (EXT7), U4.19 (Q7)
//CPURD: P1.23 (RD), TP90.1 (1_1), U1.92 (CPURD), U6.57 (RD)
//CPUWR: P1.54 (WR), TP89.1 (1_1), U1.91 (CPUWR), U6.59 (WR)
//RAMSEL: P1.32 (WRAMSEL), U1.78 (RAMSEL), U6.15 (CS3)
//ROMSEL: P1.49 (ROMSEL), U1.77 (ROMSEL)
//SCE0: U14.28 (CE0), U15.20 (~CS)
//SCE1: U14.27 (CE1), U16.20 (~CS)
//SOE: U14.30 (OE), U15.22 (~OE), U16.22 (~OE)
//SWE: U14.36 (WE), U15.27 (~WE), U16.27 (~WE)
/~PARD: P1.4 (PARD), P5.10 (~PARD), TP24.1 (1_1), U1.68 (PARD), U2.3 (PARD), U3.7 (PARD), U6.56 (PARD), U13.46 (RD)
/~PAWR: P1.35 (PAWR), P5.9 (~PAWR), TP25.1 (1_1), U1.69 (PAWR), U2.4 (PAWR), U3.6 (PAWR), U6.58 (PAWR), U13.47 (WR)
CHR0: U2.85 (CHR0), U3.46 (CHR0)
CHR1: U2.84 (CHR1), U3.47 (CHR1)
CHR2: U2.83 (CHR2), U3.48 (CHR2)
CHR3: U2.82 (CHR3), U3.49 (CHR3)
COLOR0: U2.90 (COLOR0), U3.41 (COLOR0)
COLOR1: U2.89 (COLOR1), U3.42 (COLOR1)
COLOR2: U2.88 (COLOR2), U3.43 (COLOR2)
EXTLATCH: DA5.1 (K), DA10.1 (A), R78.2, R84.2, U1.26 (PP7), U3.29 (EXTLATCH)
FIELD: U2.95 (FIELD), U3.36 (FIELD)
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C10.2, C11.1, C12.2, C13.2, C15.2, C17.2, C19.2, C20.1, C21.1, C22.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.1, C56.1, C60.2, C61.2, C63.2, C64.2, C67.2, C68.2, C69.1, C70.1, C73.2, C74.1, C76.1, C77.1, C79.1, C80.1, C81.2, C82.1, C83.2, C84.1, C85.2, C86.2, C88.2, C89.1, C90.2, C91.1, C92.2, C93.2, C94.2, C95.2, C96.1, C97.2, C98.2, C99.1, C100.1, C101.1, C102.2, D1.1 (A), DA1.3 (A), DA2.3 (A), DA3.3 (A), DA4.3 (A), DA5.3 (A), DA12.1 (A), DA13.1 (A), DA15.1 (A), DA16.1 (A), DA17.1 (A), DA19.1 (A), DB1.3 (-), J2.4 (GND), J3.5, J3.6, J4.7, J5.7, L1.1, LED1.1 (K), P1.5 (GND), P1.36 (GND), P1.SHIELD (GND), P2.11 (GND), P4.5 (GND), P4.6 (GND), P5.23 (GND), P6.5 (GND), P6.6 (GND), P7.1, Q3.3 (C), Q5.3 (C), Q7.3 (C), Q13.2 (E), R2.2, R4.2, R5.1, R6.1, R23.1, R24.2, R26.1, R31.1, R32.1, R34.1, R36.1, R39.1, R41.1, R44.1, R45.1, R51.1, R57.2, R58.2, R64.2, R65.2, R93.1, R94.1, R95.1, R96.1, R106.1, R107.2, R111.1, TC1.1, U1.18 (GND), U1.29 (4017D2), U1.30 (4017D3), U1.31 (4017D4), U1.41 (TCKSEL0), U1.42 (TCKSEL1), U1.47 (GND), U1.49 (DRAMMODE), U1.73 (TM), U1.74 (HVCMODE), U1.75 (HALT), U1.79 (GND), U1.90 (GND), U2.1 (TST1), U2.2 (TST0), U2.22 (GND), U2.23 (HVCMODE), U2.25 (MASTER), U2.45 (GND), U2.77 (GND), U2.96 (GND), U2.99 (TST2), U3.16 (GND), U3.35 (GND), U3.68 (GND), U3.90 (TST12), U3.91 (TST13), U3.92 (TST14), U3.93 (TST15), U3.98 (HVCMODE), U3.99 (GND), U4.14 (GND), U4.20 (~CS), U5.14 (GND), U5.20 (~CS), U6.13 (CS1), U6.14 (CS2), U6.17 (GND), U6.33 (GND), U6.48 (GND), U6.64 (GND), U7.2 (GND), U7.19 (NTSC/PAL), U8.9 (GND), U10.11 (V-), U11.1 (GND), U12.2 (GND), U13.26 (GND), U13.58 (GND), U14.12 (GND), U14.52 (GND), U15.14 (GND), U16.14 (GND), U17.1 (4/8_fs_SEL), U17.2 (D.GND), U17.12 (A.GND), U17.14 (LRSEL/RSI), U18.10 (GND), VA1.2
HCLD: U2.92 (HCLD), U3.39 (HCLD)
unnamed: C1.2, R1.1, X1.1
unnamed: C2.2, TC1.2, U18.1 (XTAL), X1.2
unnamed: C3.2, R3.1
unnamed: C6.1, R10.1, R11.2
unnamed: C7.1, R15.1, R16.2
unnamed: C8.1, R20.2, R21.1
unnamed: C9.2, R28.2
unnamed: C11.2, L1.2, R28.1, R29.2
unnamed: C13.1, C14.1, R35.2
unnamed: C15.1, C16.1, R37.2
unnamed: C18.2, R40.1, R41.2
unnamed: C23.1, R53.2
unnamed: C24.1, R54.2
unnamed: C25.1, R55.2
unnamed: C26.1, R60.2
unnamed: C27.1, R61.2
unnamed: C28.1, R62.2
unnamed: C30.1, J1.2, T1.2
unnamed: C30.2, J1.1, T1.1
unnamed: C31.1, DB1.2, T1.3
unnamed: C31.2, C59.2, DB1.4, T1.4
unnamed: C65.1, R67.1
unnamed: C66.2, R70.1
unnamed: C74.2, R99.1, R101.2
unnamed: C75.2, R101.1, R102.2
unnamed: C77.2, R103.1, R104.2
unnamed: C78.2, R104.1, R105.2
unnamed: D2.2 (A), D3.2 (A), O4.1, P7.11
unnamed: D2.1 (K), J4.1
unnamed: D3.1 (K), J5.1
unnamed: C20.2, D4.2 (A), J4.3
unnamed: D4.1 (K), D7.1 (K), P7.2
unnamed: C21.2, D5.2 (A), J4.2
unnamed: D5.1 (K), P7.4
unnamed: C56.2, D6.2 (A), J5.2
unnamed: D6.1 (K), P7.3
unnamed: C55.2, D7.2 (A), J5.3
unnamed: C61.1, DA6.1 (A), R50.1, R51.2, U10.3 (+), U10.5 (+)
unnamed: C60.1, DA11.2 (A), R72.2
unnamed: C33.1, C34.1, C63.1, DA11.1 (K), P3.1, Q18.3 (C), R76.2, U12.1 (IN), VA1.1
unnamed: C59.1, DA11.3 (common)
unnamed: DA12.2 (A), R7.2
unnamed: C44.1, DA12.3 (K), DA20.2 (A), P4.1 (Red)
unnamed: DA13.2 (A), R17.2
unnamed: C47.1, DA13.3 (K), DA14.2 (A), P4.4 (Blue)
unnamed: DA15.2 (A), R33.2
unnamed: C50.1, DA15.3 (K), DA18.1 (A), P4.9 (CV)
unnamed: DA16.2 (A), R25.2
unnamed: C48.1, DA16.3 (K), DA18.2 (A), P4.7 (Y-SV), R42.2
unnamed: DA17.2 (A), R46.2
unnamed: C49.1, DA17.3 (K), DA20.1 (A), P4.8 (C-SV)
unnamed: DA19.2 (A), R12.2
unnamed: C45.1, DA14.1 (A), DA19.3 (K), P4.2 (Green)
unnamed: C67.1, DB1.1 (+), F1.1
unnamed: C22.1, J2.3 (Audio), R68.1, R71.1
unnamed: J2.2 (Video), R30.1, R111.2, U7.7 (VO)
unnamed: J3.1, P6.1 (Red)
unnamed: J3.2, P6.2 (Green)
unnamed: J3.3, P6.3 (CSYNC)
unnamed: J3.4, P6.4 (Blue)
unnamed: J3.7, P6.7 (Y-SV)
unnamed: J3.8, P6.8 (C-SV)
unnamed: J3.9, P6.9 (CV)
unnamed: J3.10, P6.10 (VCC)
unnamed: J3.11, P6.11 (Audio-L)
unnamed: J3.12, P6.12 (Audio-R)
unnamed: J4.4, P7.6
unnamed: J4.5, P7.5
unnamed: J4.6, P7.10
unnamed: J5.4, P7.8
unnamed: J5.5, P7.7
unnamed: J5.6, P7.9
unnamed: LED1.2 (A), O4.2
unnamed: P1.24 (CIC0), U8.2 (P01)
unnamed: P1.55 (CIC1), U8.1 (P00)
unnamed: P1.25 (CIC2), U8.11
unnamed: C70.2, P1.56 (CIC3), U18.7 (CIC3)
unnamed: P1.2 (EXPAND), P5.24 (EXPAND), R97.1, TP19.1 (1_1)
unnamed: P1.33 (REFRESH), U1.40 (REFRESH), U6.7 (REFRESH)
unnamed: C28.2, P1.31 (SOUND-L), R96.2
unnamed: C25.2, P1.62 (SOUND-R), R95.2
unnamed: C39.1, P2.6 (4016.D0), R87.1, TP34.1 (1_1)
unnamed: C40.1, P2.7 (4016.D1), R88.1, TP30.1 (1_1)
unnamed: C37.1, P2.4 (4017.D0), R85.1, TP33.1 (1_1)
unnamed: C38.1, P2.5 (4017.D1), R86.1, TP29.1 (1_1)
unnamed: C41.1, P2.8 (JPCLK1), R89.1, TP35.1 (1_1)
unnamed: C42.1, P2.9 (JPCLK2), R90.1, TP31.1 (1_1)
unnamed: C35.1, P2.2 (JPIO6), R83.1, TP32.1 (1_1)
unnamed: C36.1, P2.3 (JPIO7), R84.1, TP28.1 (1_1)
unnamed: C43.1, P2.10 (JPSTR), R91.1, TP36.1 (1_1)
unnamed: C32.1, F1.2, P3.2
unnamed: C51.1, C66.1, P4.11 (Audio-L)
unnamed: C52.1, C65.2, P4.12 (Audio-R)
unnamed: C68.1, P5.22 (DOTCK), R98.1, TP27.1 (1_1)
unnamed: P5.25 (MONO-OUT), R66.1, R69.1, TP20.1 (1_1)
unnamed: C27.2, P5.27 (SL-IN), R94.2, TP22.1 (1_1)
unnamed: P5.21 (SMPCK), TP26.1 (1_1), U14.78 (DCK)
unnamed: C24.2, P5.28 (SR-IN), R93.2, TP23.1 (1_1)
unnamed: Q3.1 (B), U3.95 (R)
unnamed: Q3.2 (E), R8.2, R10.2
unnamed: Q4.1 (B), R8.1, R9.2
unnamed: Q4.2 (E), R4.1, R7.1
unnamed: Q5.1 (B), U3.96 (G)
unnamed: Q5.2 (E), R13.2, R15.2
unnamed: Q6.1 (B), R13.1, R14.2
unnamed: Q6.2 (E), R5.2, R12.1
unnamed: Q7.1 (B), U3.97 (B)
unnamed: Q7.2 (E), R18.1, R20.1
unnamed: Q8.1 (B), R18.2, R19.1
unnamed: Q8.2 (E), R6.2, R17.1
unnamed: C86.1, Q9.1 (B), R22.2, R23.2, R108.1
unnamed: Q9.2 (E), R24.1, R25.1
unnamed: C12.1, Q10.1 (B), R30.2, R31.2, R109.1
unnamed: Q10.2 (E), R32.2, R33.1
unnamed: C17.1, Q11.1 (B), R38.1, R39.2
unnamed: Q11.2 (E), R40.2, R42.1
unnamed: C19.1, Q12.1 (B), R43.1, R44.2, R110.1
unnamed: Q12.2 (E), R45.2, R46.1
unnamed: Q13.1 (B), R48.1
unnamed: Q13.3 (C), R49.1, R52.2, R59.2
unnamed: C53.1, Q14.1 (B), R52.1
unnamed: Q14.3 (C), Q16.1 (B), R56.1, R57.1, U10.7
unnamed: Q14.2 (E), R53.1, R54.1, R55.1, R56.2, U10.6 (-)
unnamed: C54.1, Q15.1 (B), R59.1
unnamed: Q15.3 (C), Q17.1 (B), R63.1, R64.1, U10.1
unnamed: Q15.2 (E), R60.1, R61.1, R62.1, R63.2, U10.2 (-)
unnamed: Q16.2 (E), R58.1, R66.2, R67.2, R68.2
unnamed: Q17.2 (E), R65.1, R69.2, R70.2, R71.2
unnamed: C64.1, Q18.1 (B), R76.1
unnamed: R1.2, U18.2 (XTAL)
unnamed: R2.1, U18.11
unnamed: R3.2, U18.12, U18.13
unnamed: U1.43 (HBLANK), U3.25 (HBLANK)
unnamed: TP1.1 (1_1), U1.38 (JOY-OUT1)
unnamed: TP2.1 (1_1), U1.39 (JOY-OUT2)
unnamed: U1.44 (VBLANK), U3.26 (VBLANK)
unnamed: R98.2, U3.27 (5MOUT)
unnamed: U3.1 (BURST), U7.3 (PCP), U7.16 (BFP)
unnamed: U3.100 (CSYNC), U7.8 (SYNC)
unnamed: R74.2, U3.28 (RESOUT1)
unnamed: C14.2, U7.10 ((B-Y)I)
unnamed: R34.2, R35.1, U7.24 ((B-Y)O)
unnamed: C16.2, U7.11 ((R-Y)I)
unnamed: R36.2, R37.1, U7.1 ((R-Y)O)
unnamed: C8.2, U7.22 (AB)
unnamed: C7.2, U7.21 (AG)
unnamed: C6.2, U7.20 (AR)
unnamed: R26.2, U7.12 (BLA)
unnamed: R43.2, U7.6 (CO)
unnamed: C9.1, R27.1, U7.14 (VB)
unnamed: C10.1, R27.2, U7.13 (VC)
unnamed: C18.1, U7.9 (YI)
unnamed: R22.1, R38.2, U7.23 (YO)
unnamed: C62.2, U8.3 (P02)
unnamed: C29.2, SW1.1, SW2.1, U8.8 (RES)
unnamed: C79.2, R105.1, U10.10 (+)
unnamed: C26.2, C78.1, R107.1, U10.8, U10.9 (-)
unnamed: C76.2, R102.1, U10.12 (+)
unnamed: C23.2, C75.1, R106.2, U10.13 (-), U10.14
unnamed: U13.5 (CPUA0), U14.60 (A0)
unnamed: U13.4 (CPUA1), U14.61 (A1)
unnamed: U13.3 (CPUA2), U14.62 (A2)
unnamed: U13.2 (CPUA3), U14.63 (A3)
unnamed: U13.1 (CPUA4), U14.64 (A4)
unnamed: U13.64 (CPUA5), U14.65 (A5)
unnamed: U13.63 (CPUA6), U14.66 (A6)
unnamed: U13.62 (CPUA7), U14.67 (A7)
unnamed: U13.61 (CPUA8), U14.68 (A8)
unnamed: U13.60 (CPUA9), U14.69 (A9)
unnamed: U13.59 (CPUA10), U14.70 (A10)
unnamed: U13.56 (CPUA11), U14.71 (A11)
unnamed: U13.55 (CPUA12), U14.72 (A12)
unnamed: U13.54 (CPUA13), U14.74 (A13)
unnamed: U13.53 (CPUA14), U14.75 (A14)
unnamed: U13.52 (CPUA15), U14.76 (A15)
unnamed: U13.13 (CPUD0), U14.51 (D0)
unnamed: U13.12 (CPUD1), U14.53 (D1)
unnamed: U13.11 (CPUD2), U14.54 (D2)
unnamed: U13.10 (CPUD3), U14.55 (D3)
unnamed: U13.9 (CPUD4), U14.56 (D4)
unnamed: U13.8 (CPUD5), U14.57 (D5)
unnamed: U13.7 (CPUD6), U14.58 (D6)
unnamed: U13.6 (CPUD7), U14.59 (D7)
unnamed: U13.16 (CPUK), U14.48 (CPUK)
unnamed: TP71.1 (1_1), U13.17 (P5RD)
unnamed: TP70.1 (1_1), U13.25 (P50)
unnamed: TP69.1 (1_1), U13.24 (P51)
unnamed: TP68.1 (1_1), U13.23 (P52)
unnamed: TP67.1 (1_1), U13.22 (P53)
unnamed: TP66.1 (1_1), U13.21 (P54)
unnamed: TP65.1 (1_1), U13.20 (P55)
unnamed: TP64.1 (1_1), U13.19 (P56)
unnamed: TP63.1 (1_1), U13.18 (P57)
unnamed: U13.15 (PD2), U14.49 (PD2)
unnamed: U13.14 (PD3), U14.50 (PD3)
unnamed: TP38.1 (1_1), U13.36 (T0)
unnamed: TP37.1 (1_1), U13.35 (T1)
unnamed: U14.42 (BCK), U17.16 (CLK)
unnamed: U14.44 (DATA), U17.15 (SI/LSI)
unnamed: TP92.1 (1_1), U14.43 (LRCK), U17.13 (LRCK/WDCK)
unnamed: TP93.1 (1_1), U14.45 (XTAL0), X2.2
unnamed: TP91.1 (1_1), U14.46 (XTAL1), X2.1
unnamed: R47.1, R48.2, U14.39 (~MUTE)
unnamed: R103.2, U17.11 (L.OUT)
unnamed: C73.1, U17.9 (R.REF), U17.10 (L.REF)
unnamed: R99.2, U17.6 (R.OUT)
unnamed: C4.2, U8.7 (CL1), U18.6 (3.546M)
unnamed: C69.2, R29.1, U18.5 (4.433M)
unnamed: U18.8, U18.9
unnamed: R73.2, U18.4 (XOUT)
OVER: U2.94 (~OVER), U3.37 (OVER1), U3.50 (OVER2)
PRIO0: U2.87 (PRIO0), U3.44 (PRIO0)
PRIO1: U2.86 (PRIO1), U3.45 (PRIO1)
SYSCK: P1.57 (SYSCK), U1.72 (SYSCK), U6.6 (SYSCK)
VCC: C29.1, C62.1, C81.1, C82.2, C83.1, C84.2, C85.1, C88.1, C89.2, C90.1, C91.2, C92.1, C93.1, C94.1, C95.1, C96.2, C97.1, C98.1, C99.2, C100.2, C101.2, C102.1, DA6.3 (K), DA7.3 (K), DA8.3 (K), DA9.3 (K), DA10.3 (K), DA14.3 (K), DA18.3 (K), DA20.3 (K), J2.1 (+B), P1.27 (+5V), P1.58 (+5V), P2.1 (VCC), P4.10 (VCC), P5.20 (Vcc), Q4.3 (C), Q6.3 (C), Q8.3 (C), Q9.3 (C), Q10.3 (C), Q11.3 (C), Q12.3 (C), R9.1, R11.1, R14.1, R16.1, R19.2, R21.2, R75.2, R77.1, R78.1, R79.1, R80.1, R81.1, R82.1, R92.1, R97.2, R108.2, R109.2, R110.2, SW1.2, SW2.2, U1.1 (VCC), U1.34 (VCC), U1.45 (NMI), U1.59 (VCC), U1.76 (ABORT), U1.81 (RDY), U1.85 (VCC), U2.13 (VCC), U2.24 (PALMODE), U2.26 (EXTSYNC), U2.36 (VCC), U2.62 (VCC), U2.81 (VCC), U3.5 (VCC), U3.30 (PALMODE), U3.32 (VCC), U3.59 (VCC), U3.83 (VCC), U3.94 (AVCC), U4.28 (VCC), U5.28 (VCC), U6.1 (VCC), U6.10 (CS1), U6.11 (CS2), U6.12 (CS3), U6.16 (VCC), U6.32 (VCC), U6.49 (VCC), U6.51 (PS2), U6.52 (PS3), U7.4 (SW), U7.5 (VCC), U8.4 (P03), U8.18 (VCC), U11.3 (VCC), U12.3 (OUT), U13.57 (Vcc), U14.33 (Vcc), U14.73 (Vcc), U15.28 (VCC), U16.28 (VCC), U17.3 (NC), U17.4 (D.Vdd), U17.7 (A.Vdd), U17.8 (A.Vdd), U18.3 (+5V), U18.14 (+5V?)
VCLD: U2.91 (VCLD), U3.40 (VCLD)
XIN: C5.2, P1.1 (MCK_21M), R73.1, U1.48 (MCK), U2.100 (XIN), U3.31 (XIN)
/IRQ: P1.18 (IRQ), P5.26 (~IRQ), R92.2, TP21.1 (1_1), U1.46 (IRQ)
/RESOUT0: U2.98 (RESET), U3.33 (RESOUT0)
/RESOUT1: P1.26 (RESET), P5.19 (~RESET), R74.1, R75.1, U1.50 (RESET), U6.8 (RESET), U11.2 (~RESET), U13.37 (RESET), U14.47 (RESET)
/VAWR: U2.78 (VAWR), U5.27 (~WE)
/VBWR: U2.79 (VBWR), U4.27 (~WE)
/VRD: U2.80 (VRD), U4.22 (~OE), U5.22 (~OE)
~RESET: U3.34 (~RESET), U8.10
